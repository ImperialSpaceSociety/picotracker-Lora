# Keil uVision project Blinky.uvprojx, settings and files
target STM32L152 Flash (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32L152RB STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0-dev0
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Blinky
  c flags: Optim=1
  c define: HSI_VALUE=16000000
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Source Files
    ./: Blinky.c STM32L1xx_MD_OPT.s
  group Documentation
    ./: Abstract.txt
target STM32L152 OPT (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32L152RB STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0-dev0
  cpu: as above
  output: Blinky
  c flags: Optim=1
  c define: HSI_VALUE=16000000
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
target STM32L152 RAM (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32L152RB STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0-dev0
  cpu: as above
  output: Blinky
  c flags: Optim=1
  c define: VECT_TAB_SRAM HSI_VALUE=16000000
  memory RVCT4: ROM 0x20000000 size 0x2000
  memory RVCT9: RAM 0x20002000 size 0x2000
software components: CMSIS:CORE 5.0.0, Board Support:Buttons 1.0.0, Board Support:LED 1.0.0, Device:Startup 2.0.0
