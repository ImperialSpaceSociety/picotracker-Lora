# Keil uVision project Lora.uvprojx, settings and files
target 1.1a_variant (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L072CZYx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.1
  cpu: IROM(0x08000000,0x00030000) IRAM(0x20000000,0x00005000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Picotracker_lora +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32L072xx,USE_ICSS_LORATRACKERV1_1A,USE_HAL_DRIVER, REGION_AS923, REGION_AU915, REGION_CN779, REGION_EU868, REGION_KR920, REGION_IN865, REGION_US915, REGION_RU864,VARIANT_1V1A
  c misc: --C99
  c include: ..\LoRaWAN\App\inc;..\Core\inc;..\..\..\..\..\..\Drivers\BSP\CMWX1ZZABZ-0xx;..\..\..\..\..\..\Drivers\STM32L0xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L0xx\Include;..\..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\..\Middlewares\Third_Party\LoRaWAN\Crypto;..\..\..\..\..\..\Middlewares\Third_Party\LoRaWAN\Mac;..\..\..\..\..\..\Middlewares\Third_Party\LoRaWAN\Phy;..\..\..\..\..\..\Middlewares\Third_Party\LoRaWAN\Utilities;..\..\..\..\..\..\Middlewares\Third_Party\LoRaWAN\Core;..\..\..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\..\..\Drivers\BSP\Components\hts221;..\..\..\..\..\..\Drivers\BSP\Components\lps22hb;..\..\..\..\..\..\Drivers\BSP\Components\lps25hb;..\..\..\..\..\..\Drivers\BSP\Components\sx1276;..\..\..\..\..\..\Drivers\BSP\X_NUCLEO_IKS01A1;..\..\..\..\..\..\Drivers\BSP\X_NUCLEO_IKS01A2;..\..\..\..\..\..\Drivers\BSP\B-L072Z-LRWAN1;..\..\..\..\..\..\Drivers\BSP\ICSS_LORATRACKER_V1_1A;..\..\..\..\..\..\Middlewares\Third_Party\LoRaWAN\Mac\region;..\..\..\..\..\..\Drivers\BSP\Components\ublox;..\..\..\..\..\..\Drivers\BSP\Components\ms5607
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/sx1276/: sx1276.c
    ../../../../../../Drivers/BSP/Components/ublox/: geofence.c ublox.c ublox_ubx_messages.c
    ../../../../../../Drivers/BSP/Components/ms5607/: ms5607.c
  group Drivers/BSP/CMWX1ZZABZ-0xx
    ../../../../../../Drivers/BSP/CMWX1ZZABZ-0xx/: mlm32l07x01.c
  group Drivers/BSP/ICSS_LORATRACKER
    ../../../../../../Drivers/BSP/ICSS_LORATRACKER_V1_1A/: ICSS_LoraTracker_V1.1a.c
  group Drivers/CMSIS
    ../../../../../../Drivers/CMSIS/Device/ST/STM32L0xx/Source/Templates/: system_stm32l0xx.c
  group Drivers/STM32L0xx_HAL_Driver
    ../../../../../../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_spi.c stm32l0xx_hal_uart.c stm32l0xx_hal_adc.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal.c stm32l0xx_hal_cortex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_dma.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_i2c.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c
  group Projects/MDK-ARM
    ./: startup_stm32l072xx.s
  group Projects/End_Node
    ../LoRaWAN/App/src/: main.c bsp.c debug.c hw_gpio.c hw_rtc.c hw_spi.c vcom.c hw_i2c.c i2c_middleware.c
    ../Core/src/: mlm32l0xx_hal_msp.c mlm32l0xx_hw.c mlm32l0xx_it.c
  group Middlewares/LoRaWAN/Core
    ../../../../../../Middlewares/Third_Party/LoRaWAN/Core/: lora.c lora-test.c
  group Middlewares/LoRaWAN/Mac
    ../../../../../../Middlewares/Third_Party/LoRaWAN/Mac/: LoRaMac.c LoRaMacCrypto.c LoRaMacClassB.c LoRaMacCommands.c LoRaMacConfirmQueue.c LoRaMacFCntHandler.c LoRaMacParser.c LoRaMacSerializer.c LoRaMacAdr.c
  group Middlewares/LoRaWAN/Mac/Regions
    ../../../../../../Middlewares/Third_Party/LoRaWAN/Mac/region/: Region.c RegionAS923.c RegionAU915.c RegionCN470.c RegionCN779.c RegionCommon.c RegionEU433.c RegionEU868.c RegionIN865.c RegionKR920.c RegionUS915.c RegionRU864.c
  group Middlewares/LoRaWAN/Utilities
    ../../../../../../Middlewares/Third_Party/LoRaWAN/Utilities/: low_power_manager.c timeServer.c utilities.c queue.c trace.c systime.c
  group Middlewares/LoRaWAN/Crypto
    ../../../../../../Middlewares/Third_Party/LoRaWAN/Crypto/: aes.c cmac.c soft-se.c
target 1.1b_variant (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L072CZYx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.1
  cpu: as above
  output: NUCLEO_CUBE_LORA +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32L072xx,USE_ICSS_LORATRACKERV1_1A,USE_HAL_DRIVER, REGION_AS923, REGION_AU915, REGION_CN779, REGION_EU868, REGION_KR920, REGION_IN865, REGION_US915, REGION_RU864, VARIANT_1V1B
  c misc: --C99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
target 1.2a_variant (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L072CZYx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.1
  cpu: as above
  output: Picotracker_lora +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32L072xx,USE_ICSS_LORATRACKERV1_1A,USE_HAL_DRIVER, REGION_AS923, REGION_AU915, REGION_CN779, REGION_EU868, REGION_KR920, REGION_IN865, REGION_US915, REGION_RU864,VARIANT_1V2A
  c misc: --C99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
target 1.2b_variant (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L072CZYx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.1
  cpu: as above
  output: NUCLEO_CUBE_LORA +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32L072xx,USE_ICSS_LORATRACKERV1_1A,USE_HAL_DRIVER, REGION_AS923, REGION_AU915, REGION_CN779, REGION_EU868, REGION_KR920, REGION_IN865, REGION_US915, REGION_RU864, VARIANT_1V2B
  c misc: --C99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
