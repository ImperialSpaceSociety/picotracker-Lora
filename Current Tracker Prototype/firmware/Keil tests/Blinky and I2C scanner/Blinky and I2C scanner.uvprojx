# Keil uVision project Blinky and I2C scanner.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L082CZYx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00030000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Blinky and I2C scanner
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: stdout_USART.c stdin_USART.c
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32L082CZYx/STCubeGenerated/Src/: main.c stm32l0xx_it.c
    ./RTE/Device/STM32L082CZYx/STCubeGenerated/Inc/: stm32l0xx_it.h
software components: CMSIS:CORE 5.3.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0, Device:STM32Cube HAL 1.10.0, CMSIS Driver:USART:USART Async 1.1.0, CMSIS Driver:USART:USART IrDA 1.0.0, CMSIS Driver:USART:USART SmartCard 1.0.0, CMSIS Driver:USART:USART Sync 1.0.0
