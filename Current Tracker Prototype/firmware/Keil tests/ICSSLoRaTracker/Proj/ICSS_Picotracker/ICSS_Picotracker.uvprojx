# Keil uVision project ICSS_Picotracker.uvprojx, settings and files
target LoraDunchy (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L072CZYx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.1
  cpu: IROM(0x08000000,0x00030000) IRAM(0x20000000,0x00005000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: ICSS_Picotracker +hex
  c flags: OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32L072xx,USE_B_L072Z_LRWAN1,USE_HAL_DRIVER, REGION_EU868
  c misc: --C99
  c include: inc;Core\inc;..\..\Drivers\BSP\CMWX1ZZABZ-0xx;..\..\Drivers\STM32L0xx_HAL_Driver\Inc;..\..\Drivers\CMSIS\Device\ST\STM32L0xx\Include;..\..\Drivers\CMSIS\Include;..\..\Middlewares\Third_Party\LoRaWAN\Crypto;..\..\Middlewares\Third_Party\LoRaWAN\Mac;..\..\Middlewares\Third_Party\LoRaWAN\Phy;..\..\Middlewares\Third_Party\LoRaWAN\Utilities;..\..\Middlewares\Third_Party\LoRaWAN\Core;..\..\Drivers\BSP\Components\Common;..\..\Drivers\BSP\Components\hts221;..\..\Drivers\BSP\Components\lps22hb;..\..\Drivers\BSP\Components\lps25hb;..\..\Drivers\BSP\Components\sx1276;..\..\Drivers\BSP\X_NUCLEO_IKS01A1;..\..\Drivers\BSP\X_NUCLEO_IKS01A2;..\..\Drivers\BSP\B-L072Z-LRWAN1;..\..\Middlewares\Third_Party\LoRaWAN\Mac\region
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Doc
    ./: readme.txt
  group Application
    src/: debug.c hw_gpio.c hw_rtc.c hw_spi.c main.c vcom.c
    Core/src/: mlm32l0xx_hal_msp.c mlm32l0xx_hw.c mlm32l0xx_it.c
  group Settings
    ./inc/: Commissioning.h utilities_conf.h hw_conf.h
  group STM32L0xx_HAL_Driver
    ../../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_spi.c stm32l0xx_hal_uart.c stm32l0xx_hal_adc.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal.c stm32l0xx_hal_cortex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_dma.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_i2c.c
  group Startup
    ./: startup_stm32l072xx.s
  group Drivers
    ../../Drivers/CMSIS/Device/ST/STM32L0xx/Source/Templates/: system_stm32l0xx.c
    ../../Drivers/BSP/CMWX1ZZABZ-0xx/: mlm32l07x01.c
    ../../Drivers/BSP/Components/sx1276/: sx1276.c
    ../../Drivers/BSP/ICSS_LORATRACKER_V1_1A/: ICSS_LoraTracker_V1.1a.c
  group Middlewares/LoRaWAN/Core
    ../../Middlewares/Third_Party/LoRaWAN/Core/: lora.c lora-test.c
  group Middlewares/LoRaWAN/Mac
    ../../Middlewares/Third_Party/LoRaWAN/Mac/: LoRaMac.c LoRaMacCrypto.c LoRaMacClassB.c LoRaMacCommands.c LoRaMacConfirmQueue.c LoRaMacFCntHandler.c LoRaMacParser.c LoRaMacSerializer.c LoRaMacAdr.c
  group Middlewares/LoRaWAN/Mac/Regions
    ../../Middlewares/Third_Party/LoRaWAN/Mac/region/: Region.c RegionAS923.c RegionAU915.c RegionCN470.c RegionCN779.c RegionCommon.c RegionEU433.c RegionEU868.c RegionIN865.c RegionKR920.c RegionUS915.c RegionRU864.c
  group Middlewares/LoRaWAN/Utilities
    ../../Middlewares/Third_Party/LoRaWAN/Utilities/: low_power_manager.c timeServer.c utilities.c queue.c trace.c systime.c
  group Middlewares/LoRaWAN/Crypto
    ../../Middlewares/Third_Party/LoRaWAN/Crypto/: aes.c cmac.c soft-se.c
target ICSS_PicoTracker_v1.1a (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L072CZYx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.1
  cpu: as above
  output: ICSS_Picotracker +hex
  c flags: OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32L072xx,USE_ICSS_LORATRACKERV1_1A,USE_HAL_DRIVER, REGION_EU868
  c misc: --C99
  c include: inc;Core\inc;..\..\Drivers\BSP\CMWX1ZZABZ-0xx;..\..\Drivers\STM32L0xx_HAL_Driver\Inc;..\..\Drivers\CMSIS\Device\ST\STM32L0xx\Include;..\..\Drivers\CMSIS\Include;..\..\Middlewares\Third_Party\LoRaWAN\Crypto;..\..\Middlewares\Third_Party\LoRaWAN\Mac;..\..\Middlewares\Third_Party\LoRaWAN\Phy;..\..\Middlewares\Third_Party\LoRaWAN\Utilities;..\..\Middlewares\Third_Party\LoRaWAN\Core;..\..\Drivers\BSP\Components\Common;..\..\Drivers\BSP\Components\hts221;..\..\Drivers\BSP\Components\lps22hb;..\..\Drivers\BSP\Components\lps25hb;..\..\Drivers\BSP\Components\sx1276;..\..\Drivers\BSP\X_NUCLEO_IKS01A1;..\..\Drivers\BSP\X_NUCLEO_IKS01A2;..\..\Drivers\BSP\B-L072Z-LRWAN1;..\..\Drivers\BSP\ICSS_LORATRACKER_V1_1A;..\..\Middlewares\Third_Party\LoRaWAN\Mac\region
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
